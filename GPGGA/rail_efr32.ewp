# IAR project rail_efr32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P232F256GM48 SiliconLaboratories EFR32MG1P232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFR32MG1P232F256GM48; RETARGET_VCOM; CONFIGURATION_HEADER="rail-configuration.h"; BOARD_BRD4151A
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/CMSIS/include; ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/Device/SiliconLabs/EFR32MG1P/Include; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\rtcdrv\inc; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\ustimer\inc; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\gpiointerrupt\inc; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emdrv\common\inc; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\emlib\inc; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\kits\common\bsp; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\kits\common\drivers; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\hal\efr32; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\rail_lib\common; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\utils\graphics; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\reptile\glib; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\reptile\glib\glib; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\reptile\glib\dmd; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\utils\memory_manager; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\utils\response_print; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\utils\command_interpreter; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\rail_lib\chip\efr32\rf\common\cortex; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\rail_lib\chip\efr32; ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\submodules\kits\EFR32MG1_BRD4151A\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rail.bin
  ILINK.IlinkOutputFile: rail.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Projects\Gecko\SiliconLabs\SiliconLabsRAIL\1.2.0.0-GA\autogen\librail_release\librail_efr32_iar_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFR32MG1P232F256GM48; RETARGET_VCOM; CONFIGURATION_HEADER="rail-configuration.h"; BOARD_BRD4151A
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ./: rail-callback-stubs.c rail-callbacks.c rail_config.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/hal/efr32/: hal_efr.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/hal/: hal_common.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emdrv/ustimer/src/: ustimer.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/kits/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/kits/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c dmactrl.c retargetio.c retargetserial.c udelay.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/reptile/glib/dmd/display/: dmd_display.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/reptile/glib/glib/: bmp.c glib.c glib_bitmap.c glib_circle.c glib_font_narrow_6x8.c glib_font_normal_8x8.c glib_font_number_16x20.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/utils/command_interpreter/: command_interpreter.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/utils/graphics/: graphics.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/utils/memory_manager/: buffer_pool_allocator.c rail_integration.c
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/utils/response_print/: response_print.c
  group CMSIS
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/Device/SiliconLabs/EFR32MG1P/Source/IAR/: startup_efr32mg1p.s
    ../../../../../Projects/Gecko/SiliconLabs/SiliconLabsRAIL/1.2.0.0-GA/submodules/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
